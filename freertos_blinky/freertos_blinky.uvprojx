# Keil uVision project freertos_blinky.uvprojx, settings and files
target iflash_nxp_lpcxpresso_1549 (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos_blinky +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: .\lpc_core\lpc_board\boards_15xx\nxp_lpcxpresso_1549;.\lpc_core\lpc_chip\chip_common;.\lpc_core\lpc_chip\chip_15xx;.\lpc_core\lpc_chip\chip_15xx\config_15xx;.\CMSIS;.\freeRTOS\include;.\freeRTOS\portable\RVDS\ARM_CM3;..\freertos_blinky;.\lpc_core\lpc_board\board_common;.\Example;.\freeRTOS
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group example
    ./Example/: freertos_blinky.c keil_freertos_startup_lpc15xx.s sysinit.c
  group freertos
    ./freeRTOS/: list.c queue.c tasks.c timers.c event_groups.c FreeRTOSCommonHooks.c
    ./freeRTOS/portable/MemMang/: heap_3.c
    ./freeRTOS/portable/RVDS/ARM_CM3/: port.c
  group extern
    ./lpc_core/lpc_chip/chip_common/: ring_buffer.c eeprom.c iap.c
    ./lpc_core/lpc_chip/chip_15xx/: adc_15xx.c crc_15xx.c sysctl_15xx.c clock_15xx.c gpio_15xx.c iocon_15xx.c swm_15xx.c chip_15xx.c pmu_15xx.c sysinit_15xx.c uart_15xx.c rtc_15xx.c ritimer_15xx.c wwdt_15xx.c dma_15xx.c stopwatch_15xx.c acmp_15xx.c dac_15xx.c spi_15xx.c i2cm_15xx.c i2c_common_15xx.c i2cs_15xx.c sct_15xx.c sct_pwm_15xx.c
    ./lpc_core/lpc_board/boards_15xx/nxp_lpcxpresso_1549/: board.c board_sysinit.c
software components: CMSIS:CORE 4.3.0
